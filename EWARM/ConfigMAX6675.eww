<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ConfigMAX6675.ewp</path>
  </project>
  <batchBuild />
</workspace>
